# Keil uVision project men.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: men +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 门.c pow.c 452.c
